Commit message: added suzuki parts

File: urdf/painting/door_test.urdf (robot description, URDF)
Before this commit: robot carDoor, 1 links, 0 joints
Links:
- link carDoor_base_link: geometry collision mesh filename=door_test.obj scale=1 1 1; visual mesh filename=door_test.obj scale=1 1 1
